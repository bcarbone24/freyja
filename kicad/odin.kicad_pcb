# Repository bcarbone24/freyja

## KiCad design kicad/odin.kicad_pcb

File kicad/README.md:

# Odin KiCad project

**Everything here is generated.** Do not hand-edit the `.kicad_sch` files,
`odin.kicad_sym` or `odin.pretty/` — edit the generators and re-run.

Six pages, one per functional block, from `odin.kicad_sch` (the root):

| Page | Contents |
|---|---|
| `fpga.kicad_sch` | FPGA, decoupling, configuration straps |
| `power.kicad_sch` | input, the +5V source mux, regulators, monitoring and four protected extension buses |
| `memory.kicad_sch` | PSRAM x4 (1.8 V), SDRAM, MRAM, microSD and configuration flash |
| `supervisor.kicad_sch` | RP2350B, USB-C, flash, links to the FPGA |
| `slots.kicad_sch` | Nine extension slots, rail selection, fusing, shifting |
| `network.kicad_sch` | RTL8211FD-CG PHY, ETH jack, LINK P and LINK Q |

**New to the board? Read [ref/parts-guide.md](../ref/parts-guide.md) first.**
Every part's purpose, from `tools/roles.py`, is also in the schematic (each
symbol's Description field; a paragraph inside every group box) and in the
PCB (each footprint's Description field, in the properties panel).

Parts are grouped: each regulator sits in a dashed box with its own inductor,
feedback divider and capacitors; each slot with its jumper and its fuses.
Rails and grounds use real power symbols, so only actual signals carry a
label. Rearranging by hand means giving up regeneration — a fair trade once
the design settles, just know that is the moment you make it.

## Regenerate

```bash
python3 tools/gen_kicad.py      # normalize imported XC7A100T symbol + validate FGG676 footprint + custom parts
python3 tools/ballmap.py --write
python3 tools/budget.py --write # rail qualification -> ref/power-budget.md
python3 tools/qualified.py --write   # part table -> ref/qualified-parts.md
python3 tools/roles.py --write   # what every part is for -> ref/parts-guide.md
python3 tools/audit_easyeda.py # imported symbol/pad/LCSC consistency
python3 tools/gen_project.py    # schematic from tools/design.py
python3 tools/gen_pcb.py --rules-only   # stackup, net classes, design rules; placement kept
kicad-cli sch export netlist --format kicadsexpr -o kicad/odin.net kicad/odin.kicad_sch
python3 tools/load_pcb.py       # sync footprints and nets into the board, placement kept
python3 tools/gen_xdc.py        # ref/freya.xdc and the Vivado gate top from tools/alloc.py
python3 tools/gate.py           # every phase check in one run (ref/rev-a-report.md numbers)
```

`load_pcb.py` reads `kicad/odin.net`, so export the netlist before running it
or you will load the previous revision's parts.

**Windows.** Stock KiCad libraries are found via `tools/kicadshare.py`
(`KICAD*_SYMBOL_DIR` / `KICAD*_FOOTPRINT_DIR`, else the usual install
locations). Set `PYTHONUTF8=1` first (the sources are UTF-8; Windows Python
otherwise reads cp1252). Scripts that `import pcbnew` (`load_pcb.py`,
`check_positions.py`, `place.py`, and `gate.py`, which runs them) need
KiCad's own interpreter, e.g. `"C:\Program Files\KiCad\10.0\bin\python.exe"
tools/gate.py`.

`tools/budget.py --write` currently passes and regenerates the power budget.
The input-voltage issue in findings item 20 is fixed. The command exits
non-zero if a load, input-window or inductor qualification check fails.

**`gen_pcb.py` destroys any routing.** Run it only before you start laying out;
`gen_pcb.py --rules-only` is the safe form once placement exists. `load_pcb.py`
keeps the position, rotation, side and lock of every reference already on the
board, stages new references in a band below everything else, removes
references the schematic no longer has, and refuses to save if any common
reference would move. Bracket it with `tools/check_positions.py --snapshot`
and `--compare` to prove that.

`tools/alloc.py` is the single source for ball allocation; `ref/ballmap.md` and
the schematic both come from it and cannot drift.

## Verify

The allocation is proven on the real part by a throwaway Vivado design that
uses every constrained ball (`gateware/gate/`): synthesis, place, route and
`write_bitstream` against `ref/freya.xdc`. It takes minutes, so it is not in
`gate.py`:

```bash
python3 tools/gen_xdc.py
source /tools/Xilinx/2026.1/Vivado/settings64.sh
vivado -mode batch -nojournal -nolog -source gateware/gate/run.tcl   # ends with GATE BITSTREAM OK
```

```bash
kicad-cli sch erc --severity-all -o erc.rpt odin.kicad_sch
kicad-cli pcb drc --severity-all -o drc.rpt odin.kicad_pcb
kicad-cli sch export netlist --format kicadsexpr -o odin.net odin.kicad_sch
```

```bash
kicad-cli pcb drc --schematic-parity --severity-all -o drc.rpt odin.kicad_pcb
```

## Expected ERC

Run from the repository root after regenerating the library and schematic:

```bash
python3 tools/check_erc.py
```

Expected result: **zero errors and exactly two intentional warnings**:

| Rule | Item | Reason |
|---|---|---|
| `global_label_dangling` | `FPGA_DXP` | External temperature-diode terminal is intentionally exposed only as a label. |
| `global_label_dangling` | `FPGA_DXN` | External temperature-diode terminal is intentionally exposed only as a label. |

The U20 JTAG tri-state paths currently produce **no ERC warning**: the
existing series link on TDO separates the FPGA output and bus-switch pin.
There is no U20 blanket exclusion. Any new U20 warning, or any other finding
outside the exact list above, is a regression and makes `check_erc.py` fail.
A change to the expected labels also requires updating this table and the
checker together.

`tools/gen_kicad.py` normalizes imported connector/LED pin types to passive
and models J51 SWCLK/SWDIO (pins 1/3) as bidirectional debugger connections.
J51 ground and mechanical pins remain passive. No project-level
ERC rule is disabled and no ERC exclusion is added.

The per-phase numbers (footprints, DRC, parity, escape depth) are in
[ref/rev-a-report.md](../ref/rev-a-report.md); `python3 tools/gate.py`
reproduces them. Passing the ERC allowlist does not establish fabrication
readiness.

## Your workflow from here

1. Open `odin.kicad_pcb`. Its footprints are synchronized with the
   schematic (`tools/gate.py` proves it). The connectors follow the
   mechanical placement contract; much of the remaining circuitry is still
   staged outside the board.
2. Complete placement using `tools/placement.py` / `tools/place.py` and verify
   the result in KiCad. The latest placement and validation status is in
   [ref/kicad-validation.md](../ref/kicad-validation.md). Resolve DRC findings
   as well as placement overlaps; the current reports include electrical errors.
3. Route.
4. Fabrication outputs:
   ```bash
   jlcpcb-export -p "$PWD/odin.kicad_pcb" --autoTranslate --autoFill --excludeDNP --noBackup
   ```

## Two checks that ERC and parity cannot do

`ki_fp_filters` catches a footprint that contradicts its symbol. It does not
catch a part that is the wrong part, or one that cannot survive the voltage on
its net. Two generators close that gap and both are enforced from
`tools/design.py`, so the netlist will not build if either fails:

- **`tools/qualified.py`** — MPN, manufacturer package code, footprint,
  ratings that matter here, and how the pin map was confirmed, for every
  non-generic part. A new IC cannot enter the design without an entry.
- **`tools/budget.py`** — per-rail worst-case load, regulator input window,
  inductor ripple, peak current and saturation margin. It fails if any
  inductor saturates below what its rail needs, or if a regulator's source can
  fall below its minimum input.

## LCSC part numbers — read this

Exact LCSC IDs are carried in the generated schematic/netlist for qualified
ICs, connectors and selected passives. Other passive values still need BOM
matching against the required package, tolerance and voltage rating. Use
[the import checklist](../ref/jlcpcb-import-checklist.md) and the generated
[qualified-parts table](../ref/qualified-parts.md); do not substitute a nearby
suffix without checking its package and ratings.

## Board

100 x 100 mm, **8 layers**, ENIG, nominal 1.6 mm: JLC08161H-1080A,
S / GND / S / PWR / GND / S / GND / S (F.Cu, In1 GND, In2 signal, In3 power,
In4 GND, In5 signal, In6 GND, B.Cu). In2 and In5 are the BGA escape layers,
each 0.1 mm from a ground plane; In3/In4 are a tight plane pair. Keep every
ground plane continuous under the PSRAM groups, the RGMII bus and the 100 Ω
pairs. The board is assembled on one side; B.Cu carries routing only.

Dielectrics come from JLC's template (`ref/jlc08161h-1080a-stackup.json`):
0.0764 mm 1080 prepreg outside, 0.1 mm cores, 7628/1080/7628 stacks between
the plane pairs. The 100 Ω pairs (`LVDS_100R`, `MDI_100R`) use 0.099 mm
width / 0.200 mm gap on the outer layers, from JLC's solver on that outer
prepreg; `RGMII` is 0.125 mm (estimate, confirm with JLC's calculator);
PSRAM 0.1 mm minimum width; default clearance 0.15 mm. See
[PCB impedance](../ref/pcb-impedance.md).

Regenerate stackup and rules without replacing placement or routing:
`python3 tools/gen_pcb.py --rules-only`. Net classes live in `odin.kicad_pro`;
DRC constraints live in the generated `odin.kicad_dru`.

A–H are eight logical zones carried by one continuous 2x32 through-hole
signal body on each left/right edge. Every A–H/L/M zone has a position-1 long key post and its own
1x7 female power body at positions 2..8; L and M each use a separate 2x8
through-hole signal body.

Schematic: fpga.kicad_sch

Parts:
C246, C328, C370, C371, C372, C373, C374, C375, C376, C377, C378, C379, C380, C381, C382, C383, C384, C385, C386, C387, C388, C389, C390, C391: 100nF; C_0402_1005Metric; LCSC C1525
C301: 330uF 2.5V T520V337M2R5ATE025; CP_EIA-7343-31_Kemet-D
C302, C303, C304, C305, C306, C307, C320, C321, C322, C330, C331, C336, C337, C342, C343, C348, C349, C354, C355, C360, C361: 4.7uF 6.3V; C_0805_2012Metric
C308, C309, C310, C311, C312, C313, C314, C315, C317, C318, C323, C324, C325, C326, C327, C332, C333, C334, C335, C338, C339, C340, C341, C344, C345, C346, C347, C350, C351, C352, C353, C356, C357, C358, C359, C362, C363, C364, C365: 0.47uF 6.3V; C_0603_1608Metric
C316: 100uF 2.5V; C_1210_3225Metric
C319, C329, C366, C367, C368, C369, C394: 47uF 6.3V; C_1210_3225Metric
C392, C393: 4.7uF; C_0603_1608Metric; LCSC C277476
D1: F.0603.00025/P2-0603G1TS2-06T-002; LED0603-RD_GREEN; LCSC C7496818
Q4: BSS138LT1G; SOT-23-3_L2.9-W1.6-P1.90-LS2.8-BR; LCSC C82045
R1, R2, R3, R6: 1k; R_0402_1005Metric; LCSC C11702
R4, R5, R98, R203: 4.7k; R_0402_1005Metric; LCSC C25900
R7: 330; R_0402_1005Metric
R35, R89: 100 1%; R_0603_1608Metric
R147: 33; R_0402_1005Metric; LCSC C25105
U1: XC7A100T-2FGG676I; FBGA-676_L27.0-W27.0-R26-C26-P1.00-BL; LCSC C1521803
X4: 50MHz CMOS; OSC-SMD_4P-L3.2-W2.5-BL; LCSC C717684

Connections:
+1V0: C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, C318.1, U1.J11 (VCCINT), U1.J13 (VCCINT), U1.K10 (VCCINT), U1.K12 (VCCINT), U1.L11 (VCCINT), U1.L13 (VCCINT), U1.M10 (VCCINT), U1.N13 (VCCBRAM), U1.P10 (VCCINT), U1.R13 (VCCBRAM), U1.T10 (VCCINT), U1.T12 (VCCINT), U1.U11 (VCCINT), U1.U13 (VCCBRAM), U1.V10 (VCCINT), U1.V12 (VCCINT), U1.W13 (VCCBRAM); also elsewhere on the board
+1V0_MGT: C370.1, C371.1, C372.1, C373.1, C374.1, C375.1, C376.1, C377.1, C378.1, C379.1, C392.1, U1.AA10 (MGTAVCC_G10), U1.AA12 (MGTAVCC_G10), U1.AC9 (MGTAVCC_G10), U1.AC11 (MGTAVCC_G10), U1.AC13 (MGTAVCC_G10), U1.D9 (MGTAVCC_G11), U1.D11 (MGTAVCC_G11), U1.D13 (MGTAVCC_G11), U1.F10 (MGTAVCC_G11), U1.F12 (MGTAVCC_G11); also elsewhere on the board
+1V2_MGT: C380.1, C381.1, C382.1, C383.1, C384.1, C385.1, C386.1, C387.1, C388.1, C389.1, C390.1, C391.1, C393.1, R35.2, R89.2, U1.AD7 (MGTAVTT_G10), U1.AD15 (MGTAVTT_G10), U1.AE8 (MGTAVTT_G10), U1.AE10 (MGTAVTT_G10), U1.AE12 (MGTAVTT_G10), U1.AE14 (MGTAVTT_G10), U1.B8 (MGTAVTT_G11), U1.B10 (MGTAVTT_G11), U1.B12 (MGTAVTT_G11), U1.B14 (MGTAVTT_G11), U1.C7 (MGTAVTT_G11), U1.C15 (MGTAVTT_G11); also elsewhere on the board
+1V8: C319.1, C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, C326.1, C327.1, C328.1, U1.J9 (VCCAUX), U1.L9 (VCCAUX), U1.M12 (VCCADC_0), U1.N9 (VCCAUX), U1.R9 (VCCAUX), U1.U9 (VCCAUX); also elsewhere on the board
+1V8_IO: C330.1, C331.1, C332.1, C333.1, C334.1, C335.1, C394.1, U1.AC25 (VCCO_13), U1.T16 (VCCO_13), U1.T26 (VCCO_13), U1.U23 (VCCO_13), U1.V20 (VCCO_13), U1.Y24 (VCCO_13); also elsewhere on the board
+2V5: C348.1, C349.1, C350.1, C351.1, C352.1, C353.1, C368.1, U1.A21 (VCCO_16), U1.B18 (VCCO_16), U1.C25 (VCCO_16), U1.D22 (VCCO_16), U1.E19 (VCCO_16), U1.F16 (VCCO_16); also elsewhere on the board
+3V3: C246.1, C329.1, C336.1, C337.1, C338.1, C339.1, C340.1, C341.1, C360.1, C361.1, C362.1, C363.1, C364.1, C365.1, C366.1, R1.1, R4.1, R5.1, R6.1, R7.1, R98.1, R203.1, U1.A1 (VCCO_35), U1.AA1 (VCCO_33), U1.AA21 (VCCO_12), U1.AB15 (CFGBVS_0), U1.AB18 (VCCO_12), U1.AC5 (VCCO_33), U1.AD2 (VCCO_33), U1.AD22 (VCCO_12), U1.AE19 (VCCO_12), U1.AF26 (VCCO_12), U1.C5 (VCCO_35), U1.D2 (VCCO_35), U1.F6 (VCCO_35), U1.G3 (VCCO_35), U1.J7 (VCCO_35), U1.K24 (VCCO_14), U1.L21 (VCCO_14), U1.N15 (VCCO_14), U1.N25 (VCCO_14), U1.P22 (VCCO_14), U1.R19 (VCCO_14), U1.U3 (VCCO_33), U1.W7 (VCCO_33), U1.W11 (VCCO_0), U1.W17 (VCCO_12), U1.Y4 (VCCO_33), U1.Y14 (VCCO_0), X4.1 (Tri-state), X4.4 (VDD); also elsewhere on the board
BUS5V0_DIR: U1.U24 (IO_0_13); also elsewhere on the board
BUS5V0_IO0: U1.V26 (IO_L2P_T0_13); also elsewhere on the board
BUS5V0_IO1: U1.W26 (IO_L2N_T0_13); also elsewhere on the board
BUS5V0_IO2: U1.AB26 (IO_L3P_T0_DQS_13); also elsewhere on the board
BUS5V0_IO3: U1.AC26 (IO_L3N_T0_DQS_13); also elsewhere on the board
BUS5V0_IO4: U1.U25 (IO_L1P_T0_13); also elsewhere on the board
BUS5V0_IO5: U1.U26 (IO_L1N_T0_13); also elsewhere on the board
BUS5V0_IO6: U1.W25 (IO_L4P_T0_13); also elsewhere on the board
BUS5V0_IO7: U1.Y26 (IO_L4N_T0_13); also elsewhere on the board
BUS5V0_OE_N: U1.V23 (IO_L10P_T1_13); also elsewhere on the board
BUS5V1_DIR: U1.U17 (IO_25_13); also elsewhere on the board
BUS5V1_IO0: U1.Y25 (IO_L5P_T0_13); also elsewhere on the board
BUS5V1_IO1: U1.AA25 (IO_L5N_T0_13); also elsewhere on the board
BUS5V1_IO2: U1.V24 (IO_L6P_T0_13); also elsewhere on the board
BUS5V1_IO3: U1.W24 (IO_L6N_T0_VREF_13); also elsewhere on the board
BUS5V1_IO4: U1.AA24 (IO_L7P_T1_13); also elsewhere on the board
BUS5V1_IO5: U1.AB25 (IO_L7N_T1_13); also elsewhere on the board
BUS5V1_IO6: U1.AB24 (IO_L9P_T1_DQS_13); also elsewhere on the board
BUS5V1_IO7: U1.AC24 (IO_L9N_T1_DQS_13); also elsewhere on the board
BUS5V1_OE_N: U1.W23 (IO_L10N_T1_13); also elsewhere on the board
CFG_CCLK: U1.H13 (CCLK_0); also elsewhere on the board
CFG_DONE: Q4.1 (G), R98.2, U1.W10 (DONE_0); also elsewhere on the board
CFG_INIT_B: R5.2, U1.V11 (INIT_B_0); also elsewhere on the board
CFG_M0: R1.2, U1.AB7 (M0_0)
CFG_M1: R2.1, U1.Y9 (M1_0)
CFG_M2: R3.1, U1.W9 (M2_0)
CFG_PROG_B: R4.2, U1.AE16 (PROGRAM_B_0); also elsewhere on the board
DBG_TCK: U1.N21 (IO_L13P_T2_MRCC_14); also elsewhere on the board
DBG_TDI: U1.M20 (IO_L8P_T1_D11_14); also elsewhere on the board
DBG_TDO: U1.L20 (IO_L8N_T1_D12_14); also elsewhere on the board
DBG_TMS: U1.N22 (IO_L13N_T2_MRCC_14); also elsewhere on the board
DONE_LED_A: D1.2 (A), R7.2
DONE_LED_K: D1.1 (C), Q4.3 (D)
FLASH_CS_B: R203.2, U1.P18 (IO_L6P_T0_FCS_B_14); also elsewhere on the board
FLASH_D0_MOSI: U1.R14 (IO_L1P_T0_D00_MOSI_14); also elsewhere on the board
FLASH_D1_MISO: U1.R15 (IO_L1N_T0_D01_DIN_14); also elsewhere on the board
FLASH_D2_WP: U1.P14 (IO_L2P_T0_D02_14); also elsewhere on the board
FLASH_D3_HOLD: U1.N14 (IO_L2N_T0_D03_14); also elsewhere on the board
FPGA_DXN: U1.R11 (DXN_0)
FPGA_DXP: U1.R12 (DXP_0)
GND: C246.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, C340.2, C341.2, C342.2, C343.2, C344.2, C345.2, C346.2, C347.2, C348.2, C349.2, C350.2, C351.2, C352.2, C353.2, C354.2, C355.2, C356.2, C357.2, C358.2, C359.2, C360.2, C361.2, C362.2, C363.2, C364.2, C365.2, C366.2, C367.2, C368.2, C369.2, C370.2, C371.2, C372.2, C373.2, C374.2, C375.2, C376.2, C377.2, C378.2, C379.2, C380.2, C381.2, C382.2, C383.2, C384.2, C385.2, C386.2, C387.2, C388.2, C389.2, C390.2, C391.2, C392.2, C393.2, C394.2, Q4.2 (S), R2.2, R3.2, U1.A6 (GND), U1.A8 (GND), U1.A10 (GND), U1.A11 (MGTPRXN0_216), U1.A12 (GND), U1.A13 (MGTPRXN2_216), U1.A14 (GND), U1.A16 (GND), U1.A26 (GND), U1.AA6 (GND), U1.AA9 (GND), U1.AA14 (GND), U1.AA16 (GND), U1.AA26 (GND), U1.AB3 (GND), U1.AB8 (GND), U1.AB9 (GND), U1.AB10 (GND), U1.AB12 (GND), U1.AB14 (GND), U1.AB23 (GND), U1.AC7 (GND), U1.AC12 (MGTPRXP0_213), U1.AC14 (MGTPRXP2_213), U1.AC15 (GND), U1.AC20 (GND), U1.AD6 (GND), U1.AD9 (GND), U1.AD11 (GND), U1.AD12 (MGTPRXN0_213), U1.AD13 (GND), U1.AD14 (MGTPRXN2_213), U1.AD16 (GND), U1.AE4 (GND), U1.AE6 (GND), U1.AE11 (MGTPRXP3_213), U1.AE13 (MGTPRXP1_213), U1.AE15 (GND), U1.AE24 (GND), U1.AF1 (GND), U1.AF6 (GND), U1.AF8 (GND), U1.AF10 (GND), U1.AF11 (MGTPRXN3_213), U1.AF12 (GND), U1.AF13 (MGTPRXN1_213), U1.AF14 (GND), U1.AF16 (GND), U1.AF21 (GND), U1.B3 (GND), U1.B6 (GND), U1.B11 (MGTPRXP0_216), U1.B13 (MGTPRXP2_216), U1.B15 (GND), U1.B16 (GND), U1.B23 (GND), U1.C6 (GND), U1.C9 (GND), U1.C11 (GND), U1.C12 (MGTPRXN3_216), U1.C13 (GND), U1.C14 (MGTPRXN1_216), U1.C16 (GND), U1.C20 (GND), U1.D7 (GND), U1.D12 (MGTPRXP3_216), U1.D14 (MGTPRXP1_216), U1.D15 (GND), U1.D17 (GND), U1.E4 (GND), U1.E7 (GND), U1.E8 (GND), U1.E9 (GND), U1.E10 (GND), U1.E12 (GND), U1.E14 (GND), U1.E15 (GND), U1.E24 (GND), U1.F1 (GND), U1.F9 (GND), U1.F14 (GND), U1.F21 (GND), U1.G10 (GND), U1.G11 (GND), U1.G12 (GND), U1.G13 (GND), U1.G14 (VCCBATT_0), U1.G18 (GND), U1.H5 (GND), U1.H25 (GND), U1.J2 (GND), U1.J12 (GND), U1.J22 (GND), U1.K9 (GND), U1.K11 (GND), U1.K13 (GND), U1.K19 (GND), U1.L6 (GND), U1.L10 (GND), U1.L12 (GND), U1.L16 (GND), U1.L26 (GND), U1.M3 (GND), U1.M9 (GND), U1.M11 (GNDADC_0), U1.M13 (GND), U1.M23 (GND), U1.N10 (GND), U1.N11 (VREFN_0), U1.N12 (VP_0), U1.N20 (GND), U1.P7 (GND), U1.P9 (GND), U1.P11 (VN_0), U1.P12 (VREFP_0), U1.P13 (GND), U1.P17 (GND), U1.R4 (GND), U1.R10 (GND), U1.R24 (GND), U1.T1 (GND), U1.T9 (GND), U1.T11 (GND), U1.T13 (GND), U1.T21 (GND), U1.U8 (GND), U1.U10 (GND), U1.U12 (GND), U1.U18 (GND), U1.V5 (GND), U1.V13 (GND), U1.V15 (GND), U1.V25 (GND), U1.W2 (GND), U1.W12 (GND), U1.W22 (GND), U1.Y10 (GND), U1.Y11 (GND), U1.Y12 (GND), U1.Y13 (GND), U1.Y19 (GND), X4.2 (GND); also elsewhere on the board
HDMI_CEC: U1.B2 (IO_L19N_T3_VREF_35); also elsewhere on the board
HDMI_CLK_N: U1.A2 (IO_L20N_T3_35); also elsewhere on the board
HDMI_CLK_P: U1.A3 (IO_L20P_T3_35); also elsewhere on the board
HDMI_CT_HPD: U1.F2 (IO_L22P_T3_35); also elsewhere on the board
HDMI_D0_N: U1.B1 (IO_L21N_T3_DQS_35); also elsewhere on the board
HDMI_D0_P: U1.C1 (IO_L21P_T3_DQS_35); also elsewhere on the board
HDMI_D1_N: U1.D1 (IO_L23N_T3_35); also elsewhere on the board
HDMI_D1_P: U1.E1 (IO_L23P_T3_35); also elsewhere on the board
HDMI_D2_N: U1.A5 (IO_L15N_T2_DQS_35); also elsewhere on the board
HDMI_D2_P: U1.B5 (IO_L15P_T2_DQS_35); also elsewhere on the board
HDMI_HPD: U1.B4 (IO_L16P_T2_35); also elsewhere on the board
HDMI_LS_OE: U1.E2 (IO_L22N_T3_35); also elsewhere on the board
HDMI_SCL: U1.A4 (IO_L16N_T2_35); also elsewhere on the board
HDMI_SDA: U1.C2 (IO_L19P_T3_35); also elsewhere on the board
JTAG_TCK: U1.H12 (TCK_0); also elsewhere on the board
JTAG_TDI: U1.H10 (TDI_0); also elsewhere on the board
JTAG_TDO: U1.J10 (TDO_0); also elsewhere on the board
JTAG_TMS: U1.H11 (TMS_0); also elsewhere on the board
LINK_P_RXC_N: U1.C18 (IO_L12N_T1_MRCC_16); also elsewhere on the board
LINK_P_RXC_P: U1.D18 (IO_L12P_T1_MRCC_16); also elsewhere on the board
LINK_P_RXD_N: U1.A18 (IO_L9N_T1_DQS_16); also elsewhere on the board
LINK_P_RXD_P: U1.A17 (IO_L9P_T1_DQS_16); also elsewhere on the board
LINK_P_TXC_N: U1.B26 (IO_L22N_T3_16); also elsewhere on the board
LINK_P_TXC_P: U1.C26 (IO_L22P_T3_16); also elsewhere on the board
LINK_P_TXD_N: U1.A24 (IO_L21N_T3_DQS_16); also elsewhere on the board
LINK_P_TXD_P: U1.A23 (IO_L21P_T3_DQS_16); also elsewhere on the board
LINK_Q_RXC_N: U1.D20 (IO_L14N_T2_SRCC_16); also elsewhere on the board
LINK_Q_RXC_P: U1.E20 (IO_L14P_T2_SRCC_16); also elsewhere on the board
LINK_Q_RXD_N: U1.A20 (IO_L15N_T2_DQS_16); also elsewhere on the board
LINK_Q_RXD_P: U1.B20 (IO_L15P_T2_DQS_16); also elsewhere on the board
LINK_Q_TXC_N: U1.A25 (IO_L20N_T3_16); also elsewhere on the board
LINK_Q_TXC_P: U1.B25 (IO_L20P_T3_16); also elsewhere on the board
LINK_Q_TXD_N: U1.A22 (IO_L17N_T2_16); also elsewhere on the board
LINK_Q_TXD_P: U1.B22 (IO_L17P_T2_16); also elsewhere on the board
MGTRREF: R35.1, U1.A15 (MGTRREF_216)
MGTRREF_213: R89.1, U1.AF15 (MGTRREF_213)
MRAM_CS: U1.K25 (IO_L7P_T1_D09_14); also elsewhere on the board
MRAM_SCK: U1.K26 (IO_L7N_T1_D10_14); also elsewhere on the board
MRAM_SI: U1.L24 (IO_L9P_T1_DQS_14); also elsewhere on the board
MRAM_SO: U1.L25 (IO_L9N_T1_DQS_D13_14); also elsewhere on the board
PHY_INT_N: U1.G2 (IO_L24P_T3_35); also elsewhere on the board
PHY_MDC: U1.C17 (IO_L7P_T1_16); also elsewhere on the board
PHY_MDIO: U1.B17 (IO_L7N_T1_16); also elsewhere on the board
PHY_RESET_N: U1.G1 (IO_L24N_T3_35); also elsewhere on the board
PHY_RXC: U1.D19 (IO_L13P_T2_MRCC_16); also elsewhere on the board
PHY_RXD0: U1.C19 (IO_L13N_T2_MRCC_16); also elsewhere on the board
PHY_RXD1: U1.H17 (IO_0_16); also elsewhere on the board
PHY_RXD2: U1.E22 (IO_25_16); also elsewhere on the board
PHY_RXD3: U1.B19 (IO_L10P_T1_16); also elsewhere on the board
PHY_RX_CTL: U1.A19 (IO_L10N_T1_16); also elsewhere on the board
PHY_TXC: U1.C24 (IO_L23P_T3_16); also elsewhere on the board
PHY_TXD0: U1.B24 (IO_L23N_T3_16); also elsewhere on the board
PHY_TXD1: U1.C22 (IO_L19P_T3_16); also elsewhere on the board
PHY_TXD2: U1.C23 (IO_L19N_T3_VREF_16); also elsewhere on the board
PHY_TXD3: U1.C21 (IO_L16P_T2_16); also elsewhere on the board
PHY_TX_CTL: U1.B21 (IO_L16N_T2_16); also elsewhere on the board
PSRAM0_CE_B: U1.T15 (IO_L20N_T3_13); also elsewhere on the board
PSRAM0_IO0: U1.T17 (IO_L21P_T3_DQS_13); also elsewhere on the board
PSRAM0_IO1: U1.T18 (IO_L21N_T3_DQS_13); also elsewhere on the board
PSRAM0_IO2: U1.U15 (IO_L22P_T3_13); also elsewhere on the board
PSRAM0_IO3: U1.U16 (IO_L22N_T3_13); also elsewhere on the board
PSRAM0_SCK: U1.T14 (IO_L20P_T3_13); also elsewhere on the board
PSRAM1_CE_B: U1.V14 (IO_L23N_T3_13); also elsewhere on the board
PSRAM1_IO0: U1.V16 (IO_L24P_T3_13); also elsewhere on the board
PSRAM1_IO1: U1.V17 (IO_L24N_T3_13); also elsewhere on the board
PSRAM1_IO2: U1.V18 (IO_L19P_T3_13); also elsewhere on the board
PSRAM1_IO3: U1.W18 (IO_L19N_T3_VREF_13); also elsewhere on the board
PSRAM1_SCK: U1.U14 (IO_L23P_T3_13); also elsewhere on the board
PSRAM2_CE_B: U1.U19 (IO_L17N_T2_13); also elsewhere on the board
PSRAM2_IO0: U1.V19 (IO_L18P_T2_13); also elsewhere on the board
PSRAM2_IO1: U1.W19 (IO_L18N_T2_13); also elsewhere on the board
PSRAM2_IO2: U1.T20 (IO_L15P_T2_DQS_13); also elsewhere on the board
PSRAM2_IO3: U1.U20 (IO_L15N_T2_DQS_13); also elsewhere on the board
PSRAM2_SCK: U1.T19 (IO_L17P_T2_13); also elsewhere on the board
PSRAM3_CE_B: U1.Y20 (IO_L16N_T2_13); also elsewhere on the board
PSRAM3_IO0: U1.W21 (IO_L14P_T2_SRCC_13); also elsewhere on the board
PSRAM3_IO1: U1.Y21 (IO_L14N_T2_SRCC_13); also elsewhere on the board
PSRAM3_IO2: U1.Y22 (IO_L11P_T1_SRCC_13); also elsewhere on the board
PSRAM3_IO3: U1.Y23 (IO_L11N_T1_SRCC_13); also elsewhere on the board
PSRAM3_SCK: U1.W20 (IO_L16P_T2_13); also elsewhere on the board
PUDC_B: R6.2, U1.P15 (IO_L3P_T0_DQS_PUDC_B_14)
SB_UART_RX: U1.P20 (IO_L14P_T2_SRCC_14); also elsewhere on the board
SB_UART_TX: U1.P21 (IO_L14N_T2_SRCC_14); also elsewhere on the board
SDRAM_A0: U1.M26 (IO_L20N_T3_A07_D23_14); also elsewhere on the board
SDRAM_A1: U1.N26 (IO_L20P_T3_A08_D24_14); also elsewhere on the board
SDRAM_A2: U1.P26 (IO_L22N_T3_A04_D20_14); also elsewhere on the board
SDRAM_A3: U1.R26 (IO_L22P_T3_A05_D21_14); also elsewhere on the board
SDRAM_A4: U1.M25 (IO_L10N_T1_D15_14); also elsewhere on the board
SDRAM_A5: U1.P25 (IO_L19N_T3_A09_D25_VREF_14); also elsewhere on the board
SDRAM_A6: U1.R25 (IO_L19P_T3_A10_D26_14); also elsewhere on the board
SDRAM_A7: U1.T25 (IO_L21N_T3_DQS_A06_D22_14); also elsewhere on the board
SDRAM_A8: U1.M24 (IO_L10P_T1_D14_14); also elsewhere on the board
SDRAM_A9: U1.N24 (IO_L15N_T2_DQS_DOUT_CSO_B_14); also elsewhere on the board
SDRAM_A10: U1.P24 (IO_L17N_T2_A13_D29_14); also elsewhere on the board
SDRAM_A11: U1.T24 (IO_L21P_T3_DQS_14); also elsewhere on the board
SDRAM_A12: U1.N23 (IO_L15P_T2_DQS_RDWR_B_14); also elsewhere on the board
SDRAM_BA0: U1.P23 (IO_L17P_T2_A14_D30_14); also elsewhere on the board
SDRAM_BA1: U1.R23 (IO_L24N_T3_A00_D16_14); also elsewhere on the board
SDRAM_CAS_N: U1.F3 (IO_L18P_T2_35); also elsewhere on the board
SDRAM_CKE: U1.K6 (IO_L10N_T1_AD15N_35); also elsewhere on the board
SDRAM_CLK: U1.K7 (IO_L10P_T1_AD15P_35); also elsewhere on the board
SDRAM_CS_N: U1.D3 (IO_L17P_T2_35); also elsewhere on the board
SDRAM_DQ0: U1.E6 (IO_L1P_T0_AD4P_35); also elsewhere on the board
SDRAM_DQ1: U1.D6 (IO_L1N_T0_AD4N_35); also elsewhere on the board
SDRAM_DQ2: U1.H8 (IO_L2P_T0_AD12P_35); also elsewhere on the board
SDRAM_DQ3: U1.G8 (IO_L2N_T0_AD12N_35); also elsewhere on the board
SDRAM_DQ4: U1.H7 (IO_L3P_T0_DQS_AD5P_35); also elsewhere on the board
SDRAM_DQ5: U1.G7 (IO_L3N_T0_DQS_AD5N_35); also elsewhere on the board
SDRAM_DQ6: U1.F8 (IO_L4P_T0_35); also elsewhere on the board
SDRAM_DQ7: U1.F7 (IO_L4N_T0_35); also elsewhere on the board
SDRAM_DQ8: U1.H6 (IO_L5P_T0_AD13P_35); also elsewhere on the board
SDRAM_DQ9: U1.G6 (IO_L5N_T0_AD13N_35); also elsewhere on the board
SDRAM_DQ10: U1.H9 (IO_L6P_T0_35); also elsewhere on the board
SDRAM_DQ11: U1.G9 (IO_L6N_T0_VREF_35); also elsewhere on the board
SDRAM_DQ12: U1.J6 (IO_L7P_T1_AD6P_35); also elsewhere on the board
SDRAM_DQ13: U1.J5 (IO_L7N_T1_AD6N_35); also elsewhere on the board
SDRAM_DQ14: U1.L8 (IO_L8P_T1_AD14P_35); also elsewhere on the board
SDRAM_DQ15: U1.K8 (IO_L8N_T1_AD14N_35); also elsewhere on the board
SDRAM_LDQM: U1.J4 (IO_L9P_T1_DQS_AD7P_35); also elsewhere on the board
SDRAM_RAS_N: U1.C3 (IO_L17N_T2_35); also elsewhere on the board
SDRAM_UDQM: U1.H4 (IO_L9N_T1_DQS_AD7N_35); also elsewhere on the board
SDRAM_WE_N: U1.E3 (IO_L18N_T2_35); also elsewhere on the board
SD_CD: U1.T23 (IO_L24P_T3_A01_D17_14); also elsewhere on the board
SD_CS: U1.L22 (IO_L11P_T1_SRCC_14); also elsewhere on the board
SD_MISO: U1.R22 (IO_L23N_T3_A02_D18_14); also elsewhere on the board
SD_MOSI: U1.T22 (IO_L23P_T3_A03_D19_14); also elsewhere on the board
SD_SCK: U1.L23 (IO_L11N_T1_SRCC_14); also elsewhere on the board
SLOTA_IO0: U1.K15 (IO_L1P_T0_AD0P_15); also elsewhere on the board
SLOTA_IO1: U1.J16 (IO_L1N_T0_AD0N_15); also elsewhere on the board
SLOTA_IO2: U1.J14 (IO_L2P_T0_AD8P_15); also elsewhere on the board
SLOTA_IO3: U1.J15 (IO_L2N_T0_AD8N_15); also elsewhere on the board
SLOTA_IO4: U1.K16 (IO_L3P_T0_DQS_AD1P_15); also elsewhere on the board
SLOTA_IO5: U1.K17 (IO_L3N_T0_DQS_AD1N_15); also elsewhere on the board
SLOTA_IO6: U1.M14 (IO_L4P_T0_15); also elsewhere on the board
SLOTA_IO7: U1.L14 (IO_L4N_T0_15); also elsewhere on the board
SLOTA_IO8: U1.M15 (IO_L5P_T0_AD9P_15); also elsewhere on the board
SLOTA_IO9: U1.L15 (IO_L5N_T0_AD9N_15); also elsewhere on the board
SLOTA_IO10: U1.M16 (IO_L6P_T0_15); also elsewhere on the board
SLOTA_IO11: U1.M17 (IO_L6N_T0_VREF_15); also elsewhere on the board
SLOTB_IO0: U1.J19 (IO_L7P_T1_AD2P_15); also elsewhere on the board
SLOTB_IO1: U1.H19 (IO_L7N_T1_AD2N_15); also elsewhere on the board
SLOTB_IO2: U1.L17 (IO_L8P_T1_AD10P_15); also elsewhere on the board
SLOTB_IO3: U1.L18 (IO_L8N_T1_AD10N_15); also elsewhere on the board
SLOTB_IO4: U1.K20 (IO_L9P_T1_DQS_AD3P_15); also elsewhere on the board
SLOTB_IO5: U1.J20 (IO_L9N_T1_DQS_AD3N_15); also elsewhere on the board
SLOTB_IO6: U1.J18 (IO_L10P_T1_AD11P_15); also elsewhere on the board
SLOTB_IO7: U1.H18 (IO_L10N_T1_AD11N_15); also elsewhere on the board
SLOTB_IO8: U1.G20 (IO_L11P_T1_SRCC_15); also elsewhere on the board
SLOTB_IO9: U1.G21 (IO_L11N_T1_SRCC_15); also elsewhere on the board
SLOTB_IO10: U1.K21 (IO_L12P_T1_MRCC_15); also elsewhere on the board
SLOTB_IO11: U1.J21 (IO_L12N_T1_MRCC_15); also elsewhere on the board
SLOTC_IO0: U1.H21 (IO_L13P_T2_MRCC_15); also elsewhere on the board
SLOTC_IO1: U1.H22 (IO_L13N_T2_MRCC_15); also elsewhere on the board
SLOTC_IO2: U1.J23 (IO_L14P_T2_SRCC_15); also elsewhere on the board
SLOTC_IO3: U1.H23 (IO_L14N_T2_SRCC_15); also elsewhere on the board
SLOTC_IO4: U1.G22 (IO_L15P_T2_DQS_15); also elsewhere on the board
SLOTC_IO5: U1.F22 (IO_L15N_T2_DQS_ADV_B_15); also elsewhere on the board
SLOTC_IO6: U1.J24 (IO_L16P_T2_A28_15); also elsewhere on the board
SLOTC_IO7: U1.H24 (IO_L16N_T2_A27_15); also elsewhere on the board
SLOTC_IO8: U1.F23 (IO_L17P_T2_A26_15); also elsewhere on the board
SLOTC_IO9: U1.E23 (IO_L17N_T2_A25_15); also elsewhere on the board
SLOTC_IO10: U1.K22 (IO_L18P_T2_A24_15); also elsewhere on the board
SLOTC_IO11: U1.K23 (IO_L18N_T2_A23_15); also elsewhere on the board
SLOTD_IO0: U1.G24 (IO_L19P_T3_A22_15); also elsewhere on the board
SLOTD_IO1: U1.F24 (IO_L19N_T3_A21_VREF_15); also elsewhere on the board
SLOTD_IO2: U1.E25 (IO_L20P_T3_A20_15); also elsewhere on the board
SLOTD_IO3: U1.D25 (IO_L20N_T3_A19_15); also elsewhere on the board
SLOTD_IO4: U1.E26 (IO_L21P_T3_DQS_15); also elsewhere on the board
SLOTD_IO5: U1.D26 (IO_L21N_T3_DQS_A18_15); also elsewhere on the board
SLOTD_IO6: U1.H26 (IO_L22P_T3_A17_15); also elsewhere on the board
SLOTD_IO7: U1.G26 (IO_L22N_T3_A16_15); also elsewhere on the board
SLOTD_IO8: U1.G25 (IO_L23P_T3_FOE_B_15); also elsewhere on the board
SLOTD_IO9: U1.F25 (IO_L23N_T3_FWE_B_15); also elsewhere on the board
SLOTD_IO10: U1.J25 (IO_L24P_T3_RS1_15); also elsewhere on the board
SLOTD_IO11: U1.J26 (IO_L24N_T3_RS0_15); also elsewhere on the board
SLOTE_IO0: U1.K3 (IO_L1P_T0_34); also elsewhere on the board
SLOTE_IO1: U1.J3 (IO_L1N_T0_34); also elsewhere on the board
SLOTE_IO2: U1.M7 (IO_L2P_T0_34); also elsewhere on the board
SLOTE_IO3: U1.L7 (IO_L2N_T0_34); also elsewhere on the board
SLOTE_IO4: U1.M4 (IO_L3P_T0_DQS_34); also elsewhere on the board
SLOTE_IO5: U1.L4 (IO_L3N_T0_DQS_34); also elsewhere on the board
SLOTE_IO6: U1.L5 (IO_L4P_T0_34); also elsewhere on the board
SLOTE_IO7: U1.K5 (IO_L4N_T0_34); also elsewhere on the board
SLOTE_IO8: U1.N7 (IO_L5P_T0_34); also elsewhere on the board
SLOTE_IO9: U1.N6 (IO_L5N_T0_34); also elsewhere on the board
SLOTE_IO10: U1.M6 (IO_L6P_T0_34); also elsewhere on the board
SLOTE_IO11: U1.M5 (IO_L6N_T0_VREF_34); also elsewhere on the board
SLOTF_IO0: U1.K1 (IO_L7P_T1_34); also elsewhere on the board
SLOTF_IO1: U1.J1 (IO_L7N_T1_34); also elsewhere on the board
SLOTF_IO2: U1.L3 (IO_L8P_T1_34); also elsewhere on the board
SLOTF_IO3: U1.K2 (IO_L8N_T1_34); also elsewhere on the board
SLOTF_IO4: U1.N1 (IO_L9P_T1_DQS_34); also elsewhere on the board
SLOTF_IO5: U1.M1 (IO_L9N_T1_DQS_34); also elsewhere on the board
SLOTF_IO6: U1.H2 (IO_L10P_T1_34); also elsewhere on the board
SLOTF_IO7: U1.H1 (IO_L10N_T1_34); also elsewhere on the board
SLOTF_IO8: U1.M2 (IO_L11P_T1_SRCC_34); also elsewhere on the board
SLOTF_IO9: U1.L2 (IO_L11N_T1_SRCC_34); also elsewhere on the board
SLOTF_IO10: U1.N3 (IO_L12P_T1_MRCC_34); also elsewhere on the board
SLOTF_IO11: U1.N2 (IO_L12N_T1_MRCC_34); also elsewhere on the board
SLOTG_IO0: U1.R3 (IO_L13P_T2_MRCC_34); also elsewhere on the board
SLOTG_IO1: U1.P3 (IO_L13N_T2_MRCC_34); also elsewhere on the board
SLOTG_IO2: U1.P4 (IO_L14P_T2_SRCC_34); also elsewhere on the board
SLOTG_IO3: U1.N4 (IO_L14N_T2_SRCC_34); also elsewhere on the board
SLOTG_IO4: U1.R1 (IO_L15P_T2_DQS_34); also elsewhere on the board
SLOTG_IO5: U1.P1 (IO_L15N_T2_DQS_34); also elsewhere on the board
SLOTG_IO6: U1.T4 (IO_L16P_T2_34); also elsewhere on the board
SLOTG_IO7: U1.T3 (IO_L16N_T2_34); also elsewhere on the board
SLOTG_IO8: U1.T2 (IO_L17P_T2_34); also elsewhere on the board
SLOTG_IO9: U1.R2 (IO_L17N_T2_34); also elsewhere on the board
SLOTG_IO10: U1.U2 (IO_L18P_T2_34); also elsewhere on the board
SLOTG_IO11: U1.U1 (IO_L18N_T2_34); also elsewhere on the board
SLOTH_IO0: U1.P6 (IO_L19P_T3_34); also elsewhere on the board
SLOTH_IO1: U1.P5 (IO_L19N_T3_VREF_34); also elsewhere on the board
SLOTH_IO2: U1.T5 (IO_L20P_T3_34); also elsewhere on the board
SLOTH_IO3: U1.R5 (IO_L20N_T3_34); also elsewhere on the board
SLOTH_IO4: U1.U6 (IO_L21P_T3_DQS_34); also elsewhere on the board
SLOTH_IO5: U1.U5 (IO_L21N_T3_DQS_34); also elsewhere on the board
SLOTH_IO6: U1.R8 (IO_L22P_T3_34); also elsewhere on the board
SLOTH_IO7: U1.P8 (IO_L22N_T3_34); also elsewhere on the board
SLOTH_IO8: U1.R7 (IO_L23P_T3_34); also elsewhere on the board
SLOTH_IO9: U1.R6 (IO_L23N_T3_34); also elsewhere on the board
SLOTH_IO10: U1.T8 (IO_L24P_T3_34); also elsewhere on the board
SLOTH_IO11: U1.T7 (IO_L24N_T3_34); also elsewhere on the board
SYS_CLK: R147.2, U1.M21 (IO_L12P_T1_MRCC_14)
SYS_CLK_OSC: R147.1, X4.3 (OUTPUT)
VCCIO_1: C342.1, C343.1, C344.1, C345.1, C346.1, C347.1, C367.1, U1.F26 (VCCO_15), U1.G23 (VCCO_15), U1.H20 (VCCO_15), U1.J17 (VCCO_15), U1.K14 (VCCO_15), U1.M18 (VCCO_15); also elsewhere on the board
VCCIO_2: C354.1, C355.1, C356.1, C357.1, C358.1, C359.1, C369.1, U1.K4 (VCCO_34), U1.L1 (VCCO_34), U1.M8 (VCCO_34), U1.N5 (VCCO_34), U1.P2 (VCCO_34), U1.T6 (VCCO_34); also elsewhere on the board

Notes on the sheet:
FPGA — FPGA, decoupling and configuration straps — HW 0.1.0-proto.1
U1 FPGA
The FPGA is the board: every user design (a NEORV32 RISC-V core, a video pipeline, a protocol bridge) runs here. Its six user I/O banks are dedicated by job: bank 13 at 1.8 V carries the four PSRAMs and the two 5 V bus translators, bank 14 the configuration flash, the board-controller sideband, the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
decap VCCINT
Decoupling for VCCINT (+1V0), which powers the FPGA core logic; quantities from UG483 Table 2-2, row FGG676 / XC7A100T. Placement rule: ref/decoupling.md.
decap VCCBRAM
Decoupling for VCCBRAM (+1V0), which powers the FPGA block RAM; quantities from UG483 Table 2-2, row FGG676 / XC7A100T. Placement rule: ref/decoupling.md.
decap VCCAUX
Decoupling for VCCAUX (+1V8), which powers the FPGA auxiliary circuits (clocking, I/O pre-drivers); quantities from UG483 Table 2-2, row FGG676 / XC7A100T. Placement rule: ref/decoupling.md.
decap VCCADC
Decoupling for VCCADC (+1V8), which powers the FPGA's on-chip ADC (XADC); not in UG483 Table 2-2; one 100 nF bypass. Placement rule: ref/decoupling.md.
decap VCCO_0
Decoupling for VCCO_0 (+3V3), which powers configuration bank 0; quantities from UG483 Table 2-2, row FGG676 / XC7A100T. Placement rule: ref/decoupling.md.
decap VCCO_13
Decoupling for FPGA I/O bank 13's supply (VCCO): 2 x 4.7 uF and 4 x 0.47 uF, UG483 Table 2-2. They keep the bank's supply steady while its outputs switch. Placement rule: ref/decoupling.md.
decap VCCO_14
Decoupling for FPGA I/O bank 14's supply (VCCO): 2 x 4.7 uF and 4 x 0.47 uF, UG483 Table 2-2. They keep the bank's supply steady while its outputs switch. Placement rule: ref/decoupling.md.
decap VCCO_15
Decoupling for FPGA I/O bank 15's supply (VCCO): 2 x 4.7 uF and 4 x 0.47 uF, UG483 Table 2-2. They keep the bank's supply steady while its outputs switch. Placement rule: ref/decoupling.md.
decap VCCO_16
Decoupling for FPGA I/O bank 16's supply (VCCO): 2 x 4.7 uF and 4 x 0.47 uF, UG483 Table 2-2. They keep the bank's supply steady while its outputs switch. Placement rule: ref/decoupling.md.
decap VCCO_34
Decoupling for FPGA I/O bank 34's supply (VCCO): 2 x 4.7 uF and 4 x 0.47 uF, UG483 Table 2-2. They keep the bank's supply steady while its outputs switch. Placement rule: ref/decoupling.md.
decap VCCO_35
Decoupling for FPGA I/O bank 35's supply (VCCO): 2 x 4.7 uF and 4 x 0.47 uF, UG483 Table 2-2. They keep the bank's supply steady while its outputs switch. Placement rule: ref/decoupling.md.
decap VCCO group +3V3
Bulk capacitor shared by every FPGA I/O bank powered from +3V3: UG483 Table 2-2 note 3 asks one 47 uF per group of up to four banks on one voltage. See ref/decoupling.md.
decap VCCO group VCCIO_1
Bulk capacitor shared by every FPGA I/O bank powered from VCCIO_1: UG483 Table 2-2 note 3 asks one 47 uF per group of up to four banks on one voltage. See ref/decoupling.md.
decap VCCO group +2V5
Bulk capacitor shared by every FPGA I/O bank powered from +2V5: UG483 Table 2-2 note 3 asks one 47 uF per group of up to four banks on one voltage. See ref/decoupling.md.
decap VCCO group VCCIO_2
Bulk capacitor shared by every FPGA I/O bank powered from VCCIO_2: UG483 Table 2-2 note 3 asks one 47 uF per group of up to four banks on one voltage. See ref/decoupling.md.
decap +1V0_MGT
Decoupling for +1V0_MGT (+1V0_MGT), which powers the unused but powered transceivers (MGTAVCC); the MGT supplies are UG482's, not in UG483 Table 2-2: one 100 nF per ball plus 4.7 uF. Placement rule: ref/decoupling.md.
decap +1V2_MGT
Decoupling for +1V2_MGT (+1V2_MGT), which powers the unused but powered transceivers (MGTAVTT); the MGT supplies are UG482's, not in UG483 Table 2-2: one 100 nF per ball plus 4.7 uF. Placement rule: ref/decoupling.md.
decap VCCO group +1V8_IO
Bulk capacitor shared by every FPGA I/O bank powered from +1V8_IO: UG483 Table 2-2 note 3 asks one 47 uF per group of up to four banks on one voltage. See ref/decoupling.md.
config straps (UG470)

Schematic: memory.kicad_sch

Parts:
C111, C112, C113, C114, C115, C250, C251, C252, C253, C254, C255, C256, C258, C259: 100nF; C_0402_1005Metric; LCSC C1525
C257, C260: 10uF; C_0805_2012Metric; LCSC C15850
J74: microSD; TF-SMD_TF-01A-NPTH; LCSC C91145
R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120, R121, R122, R123, R124, R125, R126, R127: 33; R_0402_1005Metric; LCSC C25105
R151: 22; R_0402_1005Metric
R152, R153, R154, R155, R156, R157, R158, R159, R160, R161, R174, R175, R176, R177, R178, R179, R180, R181, R182, R183, R184, R185, R186, R187, R188, R189, R190, R191, R192, R193, R194, R195, R196, R197: 10k; R_0603_1608Metric
U2, U3, U4, U5: APS6404L-SQN-SN; SOIC-8_L4.9-W3.9-P1.27-LS6.0-BL; LCSC C5360304
U6: W25Q256JVEIQ; WSON-8_L8.0-W6.10-P1.27-BL-EP; LCSC C97522
U32: W9825G6KH-6; TSOP-II-54_22.2x10.16mm_P0.8mm; LCSC C62246
U33: MR25H10CDF; DFN-8_L5.0-W6.0-P1.27-EP2.0-2VIA; LCSC C246234

Connections:
+1V8_IO: C111.1, C112.1, C113.1, C114.1, R174.1, R180.1, R186.1, R192.1, U2.8 (VDD), U3.8 (VDD), U4.8 (VDD), U5.8 (VDD); also elsewhere on the board
+3V3: C115.1, C250.1, C251.1, C252.1, C253.1, C254.1, C255.1, C256.1, C257.1, C258.1, C259.1, C260.1, J74.4 (VDD), R152.1, R154.1, R155.1, R156.1, R157.1, R158.1, R159.1, R160.1, R161.1, U6.8 (VCC), U32.1 (VDD), U32.3 (VDDQ), U32.9 (VDDQ), U32.14 (VDD), U32.27 (VDD), U32.43 (VDDQ), U32.49 (VDDQ), U33.8 (VDD); also elsewhere on the board
CFG_CCLK: U6.6 (CLK); also elsewhere on the board
FLASH_CS_B: U6.1 (~CS); also elsewhere on the board
FLASH_D0_MOSI: U6.5 (DI/IO0); also elsewhere on the board
FLASH_D1_MISO: U6.2 (DO/IO1); also elsewhere on the board
FLASH_D2_WP: U6.3 (~WP/IO2); also elsewhere on the board
FLASH_D3_HOLD: U6.7 (~HOLD/IO3); also elsewhere on the board
GND: C111.2, C112.2, C113.2, C114.2, C115.2, C250.2, C251.2, C252.2, C253.2, C254.2, C255.2, C256.2, C257.2, C258.2, C259.2, C260.2, J74.6 (VSS), J74.10 (GND), J74.11 (GND), J74.12 (GND), J74.13 (GND), R153.2, R175.2, R176.2, R177.2, R178.2, R179.2, R181.2, R182.2, R183.2, R184.2, R185.2, R187.2, R188.2, R189.2, R190.2, R191.2, R193.2, R194.2, R195.2, R196.2, R197.2, U2.4 (VSS), U3.4 (VSS), U4.4 (VSS), U5.4 (VSS), U6.4 (GND), U6.9 (EP), U32.6 (VSSQ), U32.12 (VSSQ), U32.28 (VSS), U32.41 (VSS), U32.46 (VSSQ), U32.52 (VSSQ), U32.54 (VSS), U33.4 (VSS), U33.9 (EP); also elsewhere on the board
MRAM_CS: R154.2, U33.1 (~CS); also elsewhere on the board
MRAM_HOLD: R156.2, U33.7 (~HOLD)
MRAM_SCK: U33.6 (SCK); also elsewhere on the board
MRAM_SI: U33.5 (SI); also elsewhere on the board
MRAM_SO: U33.2 (SO); also elsewhere on the board
MRAM_WP: R155.2, U33.3 (~WP)
PSRAM0_CE_B: R105.1; also elsewhere on the board
PSRAM0_CE_B_MEM: R105.2, R174.2, U2.1 (~CE)
PSRAM0_IO0: R106.1; also elsewhere on the board
PSRAM0_IO0_MEM: R106.2, R176.1, U2.5 (SI/SIO0)
PSRAM0_IO1: R107.1; also elsewhere on the board
PSRAM0_IO1_MEM: R107.2, R177.1, U2.2 (SO/SIO1)
PSRAM0_IO2: R108.1; also elsewhere on the board
PSRAM0_IO2_MEM: R108.2, R178.1, U2.3 (SIO2)
PSRAM0_IO3: R109.1; also elsewhere on the board
PSRAM0_IO3_MEM: R109.2, R179.1, U2.7 (SIO3)
PSRAM0_SCK: R104.1; also elsewhere on the board
PSRAM0_SCK_MEM: R104.2, R175.1, U2.6 (SCLK)
PSRAM1_CE_B: R111.1; also elsewhere on the board
PSRAM1_CE_B_MEM: R111.2, R180.2, U3.1 (~CE)
PSRAM1_IO0: R112.1; also elsewhere on the board
PSRAM1_IO0_MEM: R112.2, R182.1, U3.5 (SI/SIO0)
PSRAM1_IO1: R113.1; also elsewhere on the board
PSRAM1_IO1_MEM: R113.2, R183.1, U3.2 (SO/SIO1)
PSRAM1_IO2: R114.1; also elsewhere on the board
PSRAM1_IO2_MEM: R114.2, R184.1, U3.3 (SIO2)
PSRAM1_IO3: R115.1; also elsewhere on the board
PSRAM1_IO3_MEM: R115.2, R185.1, U3.7 (SIO3)
PSRAM1_SCK: R110.1; also elsewhere on the board
PSRAM1_SCK_MEM: R110.2, R181.1, U3.6 (SCLK)
PSRAM2_CE_B: R117.1; also elsewhere on the board
PSRAM2_CE_B_MEM: R117.2, R186.2, U4.1 (~CE)
PSRAM2_IO0: R118.1; also elsewhere on the board
PSRAM2_IO0_MEM: R118.2, R188.1, U4.5 (SI/SIO0)
PSRAM2_IO1: R119.1; also elsewhere on the board
PSRAM2_IO1_MEM: R119.2, R189.1, U4.2 (SO/SIO1)
PSRAM2_IO2: R120.1; also elsewhere on the board
PSRAM2_IO2_MEM: R120.2, R190.1, U4.3 (SIO2)
PSRAM2_IO3: R121.1; also elsewhere on the board
PSRAM2_IO3_MEM: R121.2, R191.1, U4.7 (SIO3)
PSRAM2_SCK: R116.1; also elsewhere on the board
PSRAM2_SCK_MEM: R116.2, R187.1, U4.6 (SCLK)
PSRAM3_CE_B: R123.1; also elsewhere on the board
PSRAM3_CE_B_MEM: R123.2, R192.2, U5.1 (~CE)
PSRAM3_IO0: R124.1; also elsewhere on the board
PSRAM3_IO0_MEM: R124.2, R194.1, U5.5 (SI/SIO0)
PSRAM3_IO1: R125.1; also elsewhere on the board
PSRAM3_IO1_MEM: R125.2, R195.1, U5.2 (SO/SIO1)
PSRAM3_IO2: R126.1; also elsewhere on the board
PSRAM3_IO2_MEM: R126.2, R196.1, U5.3 (SIO2)
PSRAM3_IO3: R127.1; also elsewhere on the board
PSRAM3_IO3_MEM: R127.2, R197.1, U5.7 (SIO3)
PSRAM3_SCK: R122.1; also elsewhere on the board
PSRAM3_SCK_MEM: R122.2, R193.1, U5.6 (SCLK)
SDRAM_A0: U32.23 (A0); also elsewhere on the board
SDRAM_A1: U32.24 (A1); also elsewhere on the board
SDRAM_A2: U32.25 (A2); also elsewhere on the board
SDRAM_A3: U32.26 (A3); also elsewhere on the board
SDRAM_A4: U32.29 (A4); also elsewhere on the board
SDRAM_A5: U32.30 (A5); also elsewhere on the board
SDRAM_A6: U32.31 (A6); also elsewhere on the board
SDRAM_A7: U32.32 (A7); also elsewhere on the board
SDRAM_A8: U32.33 (A8); also elsewhere on the board
SDRAM_A9: U32.34 (A9); also elsewhere on the board
SDRAM_A10: U32.22 (A10); also elsewhere on the board
SDRAM_A11: U32.35 (A11); also elsewhere on the board
SDRAM_A12: U32.36 (A12); also elsewhere on the board
SDRAM_BA0: U32.20 (BS0); also elsewhere on the board
SDRAM_BA1: U32.21 (BS1); also elsewhere on the board
SDRAM_CAS_N: U32.17 (~CAS); also elsewhere on the board
SDRAM_CKE: R153.1, U32.37 (CKE); also elsewhere on the board
SDRAM_CLK: R151.1; also elsewhere on the board
SDRAM_CLK_MEM: R151.2, U32.38 (CLK)
SDRAM_CS_N: R152.2, U32.19 (~CS); also elsewhere on the board
SDRAM_DQ0: U32.2 (DQ0); also elsewhere on the board
SDRAM_DQ1: U32.4 (DQ1); also elsewhere on the board
SDRAM_DQ2: U32.5 (DQ2); also elsewhere on the board
SDRAM_DQ3: U32.7 (DQ3); also elsewhere on the board
SDRAM_DQ4: U32.8 (DQ4); also elsewhere on the board
SDRAM_DQ5: U32.10 (DQ5); also elsewhere on the board
SDRAM_DQ6: U32.11 (DQ6); also elsewhere on the board
SDRAM_DQ7: U32.13 (DQ7); also elsewhere on the board
SDRAM_DQ8: U32.42 (DQ8); also elsewhere on the board
SDRAM_DQ9: U32.44 (DQ9); also elsewhere on the board
SDRAM_DQ10: U32.45 (DQ10); also elsewhere on the board
SDRAM_DQ11: U32.47 (DQ11); also elsewhere on the board
SDRAM_DQ12: U32.48 (DQ12); also elsewhere on the board
SDRAM_DQ13: U32.50 (DQ13); also elsewhere on the board
SDRAM_DQ14: U32.51 (DQ14); also elsewhere on the board
SDRAM_DQ15: U32.53 (DQ15); also elsewhere on the board
SDRAM_LDQM: U32.15 (LDQM); also elsewhere on the board
SDRAM_RAS_N: U32.18 (~RAS); also elsewhere on the board
SDRAM_UDQM: U32.39 (UDQM); also elsewhere on the board
SDRAM_WE_N: U32.16 (~WE); also elsewhere on the board
SD_CD: J74.9 (CD); also elsewhere on the board
SD_CS: J74.2 (CDDAT3(CS)), R157.2; also elsewhere on the board
SD_DAT1: J74.8 (DAT1(RSV)), R160.2
SD_DAT2: J74.1 (DAT2(RSV)), R161.2
SD_MISO: J74.7 (DAT0(D0)), R159.2; also elsewhere on the board
SD_MOSI: J74.3 (CMD(DI)), R158.2; also elsewhere on the board
SD_SCK: J74.5 (CLK(SCLK)); also elsewhere on the board

Notes on the sheet:
MEMORY — PSRAM x4 (independent buses, 1.8 V), SDRAM, MRAM, microSD and configuration flash — HW 0.1.0-proto.1
PSRAM0
Working-memory chip 0: 8 MB of fast RAM for the FPGA design, on its own four-bit (QSPI) bus to bank 13 at 1.8 V. The four chips are independent, so a design can use them in parallel. Notes: ref/psram.md.
PSRAM1
Working-memory chip 1: 8 MB of RAM on its own QSPI bus to bank 13, at 1.8 V.
PSRAM2
Working-memory chip 2: 8 MB of RAM on its own QSPI bus to bank 13, at 1.8 V.
PSRAM3
Working-memory chip 3: 8 MB of RAM on its own QSPI bus to bank 13, at 1.8 V.
config flash
The FPGA's non-volatile memory. At power-on the FPGA reads its design (bitstream) from this 32 MB flash by itself (master SPI, set by the mode straps). The board controller can rewrite it through the series resistors on the Board Controller sheet, and spare space can hold user data or software for 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
U1 PSRAM0 series termination
One 33 ohm resistor per PSRAM0 line, placed next to the FPGA: they soften the fast signal edges so they do not ring along the trace. Values can be tuned after measurement (ref/psram.md).
U1 PSRAM1 series termination
One 33 ohm resistor per PSRAM1 line, next to the FPGA, to damp ringing.
U1 PSRAM2 series termination
One 33 ohm resistor per PSRAM2 line, next to the FPGA, to damp ringing.
U1 PSRAM3 series termination
One 33 ohm resistor per PSRAM3 line, next to the FPGA, to damp ringing.
SDRAM
A 32 MB SDR SDRAM (Winbond W9825G6KH-6, 16 bits wide, up to 166 MHz) for designs that outgrow the PSRAMs: a framebuffer, a soft CPU's main memory, a capture buffer. Its data and control lines come from bank 35 and its address lines from bank 14, both at 3.3 V. One 100 nF per VDD/VDDQ pin pair (seve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
U1 SDRAM clock source
The 22 ohm resistor in the SDRAM clock line. It sits at the FPGA ball that drives the clock, so it damps the edge at its source; it is in U1's island, not the SDRAM's (findings 44).
MRAM
A 128 KB non-volatile SPI memory (Everspin MR25H10CDF) that keeps its contents without power and has no write wear: settings, logs, a boot menu, a save file. CS is pulled up so the chip stays deselected while power comes up (datasheet section 4); WP and HOLD are pulled up and not connected to the F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
microSD socket
A push-push microSD socket (Hroparts TF-01A) wired for SPI mode: chip select on DAT3, data in on CMD, data out on DAT0, clock on CLK, five bank 14 lines at 3.3 V including the card-detect switch. The 10k pull-ups hold CS, the two data lines and the two unused DAT lines high, as the SD specification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
PSRAM0 power-up state
Six 10k resistors at the PSRAM0 pins: CE# pulled up to its own supply, clock and the four data lines pulled down. The chip requires these levels from the first moment of its supply ramp until 150 us after it, and an unconfigured FPGA leaves its pins floating, so resistors, not the FPGA, guarantee t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
PSRAM1 power-up state
Six 10k resistors at the PSRAM1 pins: CE# up, clock and data down, from power-up (APS6404L section 8).
PSRAM2 power-up state
Six 10k resistors at the PSRAM2 pins: CE# up, clock and data down, from power-up (APS6404L section 8).
PSRAM3 power-up state
Six 10k resistors at the PSRAM3 pins: CE# up, clock and data down, from power-up (APS6404L section 8).
